# Keil uVision project Project.uvprojx, settings and files
target Project (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: CW32L083RC WHXY
  pack: WHXY.CW32L083_DFP.1.0.9
  cpu: IRAM(0x20000000,0x06000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 wLevel=2
  c include: ..\USER\inc;..\Libraries\inc;..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  link misc: --keep=*Handler
  group Startup
    ../Libraries/src/: system_cw32l083.c startup_cw32l083.s
  group User
    ../USER/src/: main.c interrupts_cw32l083.c rtc.c i2c.c message.c
  group Driver
    ../Libraries/src/: cw32l083_btim.c cw32l083_gpio.c cw32l083_i2c.c cw32l083_pwr.c cw32l083_rcc.c cw32l083_rtc.c cw32l083_uart.c
  group Utilities
    ../Utilities/: log.c
software components: CMSIS:CORE 5.3.0
